<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>Config_values</value></param>
<param><key>value2</key><value>20e3</value></param>
<param><key>field0</key><value>LowFreqBoundary</value></param>
<param><key>field1</key><value>HighFreqBoundary</value></param>
<param><key>field2</key><value>ChannelWidth</value></param>
<param><key>field3</key><value>TransmissionSampRate</value></param>
<param><key>value1</key><value>72.170e6 + freq</value></param>
<param><key>value0</key><value>72.170e6 + freq</value></param>
<param><key>value3</key><value>1000e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>added</value></param>
<param><key>value</key><value>0.02</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>controller_callback</value></param>
<param><key>block_id</key><value>controller</value></param>
<param><key>function_args</key><value>self</value></param>
<param><key>function_name</key><value>check_signal</value></param>
<param><key>value</key><value>1</value></param>
<param><key>poll_rate</key><value>5</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>controller_callback_0</value></param>
<param><key>block_id</key><value>controller</value></param>
<param><key>function_args</key><value>self</value></param>
<param><key>function_name</key><value>refreshUi</value></param>
<param><key>value</key><value>1</value></param>
<param><key>poll_rate</key><value>5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency_carrier</value></param>
<param><key>value</key><value>Config_values.LowFreqBoundary</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>is_demod_on</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>multiplied</value></param>
<param><key>value</key><value>-1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>probe</value></param>
<param><key>block_id</key><value>probing_block</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>1</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>variable_qtgui_range_0</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>PPM_Analog_RC_PPM_Peak_Detector</key>
<param><key>id</key><value>PPM_Analog_RC_PPM_Peak_Detector_0</value></param>
<param><key>peak_threshold</key><value>0.005</value></param>
</block>
<block>
<key>PPM_Analog_RC_PPM_Signal_Detector</key>
<param><key>id</key><value>PPM_Analog_RC_PPM_Signal_Detector_0</value></param>
<param><key>energy_threshold</key><value>10</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>PPM_Analog_RC_PPM_Demodulator</key>
<param><key>id</key><value>PPM_Demodulator</value></param>
<param><key>demod_on</key><value>is_demod_on</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>PPM_Analog_RC_PPM_Modulator</key>
<param><key>id</key><value>PPM_Modulator</value></param>
<param><key>samp_rate</key><value>Config_values.TransmissionSampRate</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>add_const_transmitter</value></param>
<param><key>const</key><value>added</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>noise_type</key><value>analog.GR_IMPULSE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>1</value></param>
<param><key>quad_rate</key><value>Config_values.ChannelWidth</value></param>
</block>
<block>
<key>analog_wfm_tx</key>
<param><key>id</key><value>analog_wfm_tx</value></param>
<param><key>audio_rate</key><value>int(Config_values.TransmissionSampRate)</value></param>
<param><key>max_dev</key><value>20e3</value></param>
<param><key>fh</key><value>0</value></param>
<param><key>quad_rate</key><value>int(Config_values.TransmissionSampRate)</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/simon/Workspace/TC-16-17/PFE/2-PPM_Analog_RC/GNU-Radio/PPM_Analog_RC.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>frequency_carrier</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_0</value></param>
<param><key>alpha</key><value>0.0001</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>0.1</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0.1</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>controller</value></param>
<param><key>channel_width</key><value>Config_values.ChannelWidth</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""
import os, struct, array
from fcntl import ioctl
import sys, tty, termios
import threading
import numpy as np
import Tkinter as tk
from gnuradio import gr
import time
import PPM_Analog_RC


class controller(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""



    def __init__(self, low_freq_boundary=72010000, high_freq_boundary=72990000, channel_width=20000):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.basic_block.__init__(
            self,
            name='PPM Demodulation controller',   # will show up in GRC
            in_sig=[],
            out_sig=[]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.low_freq_boundary = low_freq_boundary
        self.high_freq_boundary = high_freq_boundary
        self.channel_width = channel_width
        self.should_start = False
        self.found_last = [False,False]
        self.input_key = ''
        self.decode = False




    def connectTransmitter(self, obj):
        obj.lock()
        obj.connect((obj.PPM_Modulator, 0), (obj.variable_qtgui_range_00, 0))
        obj.connect((obj.add_const_transmitter, 0), (obj.analog_wfm_tx, 0))
        obj.connect((obj.analog_wfm_tx, 0), (obj.uhd_usrp_sink, 0))
        obj.connect((obj.low_pass_filter_transmitter, 0), (obj.multiply_const_transmitter, 0))
        obj.connect((obj.multiply_const_transmitter, 0), (obj.add_const_transmitter, 0))
        obj.connect((obj.root_raised_cosine_transmitter, 0), (obj.low_pass_filter_transmitter, 0))
        obj.connect((obj.variable_qtgui_range_00, 0), (obj.root_raised_cosine_transmitter, 0))


        obj.unlock()

    def disconnectTransmitter(self, obj):

        obj.lock()
        obj.disconnect((obj.PPM_Modulator, 0), (obj.variable_qtgui_range_00, 0))
        obj.disconnect((obj.add_const_transmitter, 0), (obj.analog_wfm_tx, 0))
        obj.disconnect((obj.analog_wfm_tx, 0), (obj.uhd_usrp_sink, 0))
        obj.disconnect((obj.low_pass_filter_transmitter, 0), (obj.multiply_const_transmitter, 0))
        obj.disconnect((obj.multiply_const_transmitter, 0), (obj.add_const_transmitter, 0))
        obj.disconnect((obj.root_raised_cosine_transmitter, 0), (obj.low_pass_filter_transmitter, 0))
        obj.disconnect((obj.variable_qtgui_range_00, 0), (obj.root_raised_cosine_transmitter, 0))
        obj.unlock()



    def check_signal(self, obj):
        if self.should_start == False :
            self.should_start = True
            def launchWindow():
                self.window = ui(self)
                self.window.master.title('PPM RC Hack')
                self.window.mainloop()
            self._window_thread = threading.Thread(target=launchWindow)
            self._window_thread.daemon = True
            self._window_thread.start()
            time.sleep(0.1)
            joyInput = stick(self, obj)
            self._window_thread = threading.Thread(target=joyInput.updatePositionLoop)
            self._window_thread.daemon = True
            self._window_thread.start()
            self.disconnectTransmitter(obj)
            self.transmitting = False
            self.window.freqLabel.config(text= "Frequency: " + str(self.low_freq_boundary/1000000.0) + "MHz")
            return 0

        if self.input_key == 'escape':
            self.input_key = ''
            newfreq = obj.frequency_carrier + self.channel_width   #Loop on available channels
            if (newfreq &gt; self.high_freq_boundary):
                newfreq = self.low_freq_boundary
            obj.set_frequency_carrier(newfreq)
            obj.set_is_demod_on(0)
            print 'Changing channel'
            self.window.freqLabel.config(text= "Frequency: " + str(newfreq/1000000.0) + "MHz")
            self.window.channelInfoLabel.config(text = '')
            self.found_last[0] = 0
            self.found_last[1] = False
            self.decode = False
            return 0

        if self.input_key == 'enter':       #Placeholder to switch to transmission
            self.input_key = ''
            print 'switching transmitter'
            if self.transmitting:
                self.disconnectTransmitter(obj)
                self.transmitting = False
            else:
                self.connectTransmitter(obj)
                self.transmitting = True

        if(obj.probing_block.level() &gt;=1):      #Actual check if signal is detected by the signal detector block
            if self.found_last[0] is True:      #To smooth burst of false results
                if self.found_last[1] is False: #To act only if we just arrived on this channel
                    self.window.detectedLabel.config(text='''Signal detected: press esc to continue sweep
press enter to switch to transmittion mode (not implemented yet)''')
                    obj.set_is_demod_on(1)
                    self.found_last[1] = True
                    self.decode = True
                return 1
            else:
                self.found_last[0] = True
                return 0
        else :
            if self.found_last[0] is False:
                newfreq = obj.frequency_carrier + self.channel_width   #Loop on available channels
                if (newfreq &gt; self.high_freq_boundary):
                    newfreq = self.low_freq_boundary + obj.freq
                obj.set_frequency_carrier(newfreq)
                obj.set_is_demod_on(0)

                self.window.detectedLabel.config(text=" Sweeping... ")
                self.window.freqLabel.config(text= "Frequency: " + str(newfreq/1000000.0) + "MHz")
                self.window.channelInfoLabel.config(text = '')
                self.found_last[0] = 0
                self.found_last[1] = False
                self.decode = False
                print 'Changing channel nothing found' + "  Frequency: " +str(newfreq/1000000.0) + "MHz"
                return 0
            else:
                self.found_last[0] = False
                return 1

    def refreshUi(self, obj):
        if self.decode == True:
            channelValues = obj.PPM_Demodulator.get_channels()
            nbChannels = obj.PPM_Demodulator.get_nbr_channels()
            string = str(nbChannels) + " channels detected: "
            if nbChannels &gt; 0:
                for i in xrange(1,nbChannels+1):
                    string = string + "CH" + str(i) + ": " + '{:03.2f}'.format(PPM_Analog_RC.floatArray_getitem(channelValues, index=(i-1))) + " | "
            self.window.channelInfoLabel.config(text = string)






    def work(self, input_items, output_items):
        """example: multiply with constant"""
        #output_items[0][:] = input_items[0] * self.example_param
        return len(output_items[0])








class ui(tk.Frame):
    def __init__(self, calling, master=None):
        tk.Frame.__init__(self, master)
        self.grid()
        self.createWidgets()
        self.calling = calling

    def createWidgets(self):
        self.freqLabel = tk.Label()
        self.freqLabel.grid()
        self.detectedLabel = tk.Label(text=" Sweeping... ")
        self.detectedLabel.grid()
        self.channelInfoLabel = tk.Label(text="  No channels  ")
        self.channelInfoLabel.grid()
        self.freqLabel.bind_all('&lt;KeyPress-Return&gt;', self._enterHandler)
        self.freqLabel.bind_all('&lt;KeyPress-Escape&gt;', self._escapeHandler)


    def _enterHandler(self,event):
        self.calling.input_key = 'enter'
    def _escapeHandler(self,event):
        self.calling.input_key = 'escape'



class stick():
    def __init__(self, calling, top_block):
        self.calling = calling
        self.top_block = top_block

        # Iterate over the joystick devices.
        print('Available devices:')

        for fn in os.listdir('/dev/input'):
            if fn.startswith('js'):
                print('  /dev/input/%s' % (fn))

        # We'll store the states here.
        self.axis_states = {}
        self.button_states = {}

        # These constants were borrowed from linux/input.h
        self.axis_names = {
            0x00 : 'x',
            0x01 : 'y',
            0x02 : 'z',
            0x03 : 'rx',
            0x04 : 'ry',
            0x05 : 'rz',
            0x06 : 'trottle',
            0x07 : 'rudder',
            0x08 : 'wheel',
            0x09 : 'gas',
            0x0a : 'brake',
            0x10 : 'hat0x',
            0x11 : 'hat0y',
            0x12 : 'hat1x',
            0x13 : 'hat1y',
            0x14 : 'hat2x',
            0x15 : 'hat2y',
            0x16 : 'hat3x',
            0x17 : 'hat3y',
            0x18 : 'pressure',
            0x19 : 'distance',
            0x1a : 'tilt_x',
            0x1b : 'tilt_y',
            0x1c : 'tool_width',
            0x20 : 'volume',
            0x28 : 'misc',
        }

        self.button_names = {
            0x120 : 'trigger',
            0x121 : 'thumb',
            0x122 : 'thumb2',
            0x123 : 'top',
            0x124 : 'top2',
            0x125 : 'pinkie',
            0x126 : 'base',
            0x127 : 'base2',
            0x128 : 'base3',
            0x129 : 'base4',
            0x12a : 'base5',
            0x12b : 'base6',
            0x12f : 'dead',
            0x130 : 'a',
            0x131 : 'b',
            0x132 : 'c',
            0x133 : 'x',
            0x134 : 'y',
            0x135 : 'z',
            0x136 : 'tl',
            0x137 : 'tr',
            0x138 : 'tl2',
            0x139 : 'tr2',
            0x13a : 'select',
            0x13b : 'start',
            0x13c : 'mode',
            0x13d : 'thumbl',
            0x13e : 'thumbr',

            0x220 : 'dpad_up',
            0x221 : 'dpad_down',
            0x222 : 'dpad_left',
            0x223 : 'dpad_right',

            # XBox 360 controller uses these codes.
            0x2c0 : 'dpad_left',
            0x2c1 : 'dpad_right',
            0x2c2 : 'dpad_up',
            0x2c3 : 'dpad_down',
        }

        self.axis_map = []
        self.button_map = []

        # Open the joystick device.
        fn = '/dev/input/js0'
        print('Opening %s...' % fn)
        try:
            self.jsdev = open(fn, 'rb')
        except:
            print 'No device found'
            self.controller = False
            return
        self.controller = True

        # Get the device name.
        #buf = bytearray(63)
        buf = array.array('c', ['\0'] * 64)
        ioctl(self.jsdev, 0x80006a13 + (0x10000 * len(buf)), buf) # JSIOCGNAME(len)
        js_name = buf.tostring()
        print('Device name: %s' % js_name)

        # Get number of axes and buttons.
        buf = array.array('B', [0])
        ioctl(self.jsdev, 0x80016a11, buf) # JSIOCGAXES
        num_axes = buf[0]

        buf = array.array('B', [0])
        ioctl(self.jsdev, 0x80016a12, buf) # JSIOCGBUTTONS
        num_buttons = buf[0]

        # Get the axis map.
        buf = array.array('B', [0] * 0x40)
        ioctl(self.jsdev, 0x80406a32, buf) # JSIOCGAXMAP

        for axis in buf[:num_axes]:
            axis_name = self.axis_names.get(axis, 'unknown(0x%02x)' % axis)
            self.axis_map.append(axis_name)
            self.axis_states[axis_name] = 0.0

        # Get the button map.
        buf = array.array('H', [0] * 200)
        ioctl(self.jsdev, 0x80406a34, buf) # JSIOCGBTNMAP

        for btn in buf[:num_buttons]:
            btn_name = self.button_names.get(btn, 'unknown(0x%03x)' % btn)
            self.button_map.append(btn_name)
            self.button_states[btn_name] = 0

        print '%d axes found: %s' % (num_axes, ', '.join(self.axis_map))
        print '%d buttons found: %s' % (num_buttons, ', '.join(self.button_map))

    def updatePositionLoop(self):
        if not self.controller:
            return

        # Main event loop
        while True:
            evbuf = self.jsdev.read(8)
            if evbuf:
                time, value, type, number = struct.unpack('IhBB', evbuf)

                if type &amp; 0x80:
                     print "(initial)",

                if type &amp; 0x01:
                    button = self.button_map[number]
                    if button:
                        self.button_states[button] = value
                        if value:
                            print "%s pressed" % (button)
                        else:
                            print "%s released" % (button)

                if type &amp; 0x02:
                    axis = self.axis_map[number]
                    if axis:
                        fvalue = value / 32767.0
                        self.axis_states[axis] = fvalue
                        #print "%s: %.3f" % (axis, fvalue)
                        if axis == 'trottle':
                            self.top_block.PPM_Modulator.set_axis(2, fvalue)
                        elif axis == 'y':
                            self.top_block.PPM_Modulator.set_axis(1, fvalue)
                        elif axis == 'x':
                            self.top_block.PPM_Modulator.set_axis(0, fvalue)
                        elif axis == 'rz':
                            self.top_block.PPM_Modulator.set_axis(3, fvalue)
</value></param>
<param><key>high_freq_boundary</key><value>Config_values.HighFreqBoundary</value></param>
<param><key>low_freq_boundary</key><value>Config_values.LowFreqBoundary</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>controller0</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph

#freq = 72170000
decode = 0

def check_signal(obj):
	if(obj.probing_block.level() &gt;=1):
		decode = 1
		print 'yay'
	else:
		newfreq = obj.frequency_carrier + 20000
		if newfreq &gt; 72990000:				#Loop on available channels
			newfreq = 72010000
		obj.set_frequency_carrier(newfreq)
		#obj.frequency_carrierfreq = obj.frequency_carrier + 20000
		decode = 0
		print 'truc'


</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>Config_values.ChannelWidth</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>3</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>Config_values.ChannelWidth/2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>cutoff_freq</key><value>5e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_transmitter</value></param>
<param><key>cutoff_freq</key><value>2e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>Config_values.TransmissionSampRate</value></param>
<param><key>width</key><value>8e3</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>moving_average</value></param>
<param><key>length</key><value>int(samp_rate*0.04)</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1.0/(int(samp_rate*0.04))</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>multiply_const_transmitter</value></param>
<param><key>const</key><value>multiplied</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probing_block</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.20</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Peaks"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>40240</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.01</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>20240</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.01</value></param>
<param><key>tr_level</key><value>100</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>Config_values.HighFreqBoundary</value></param>
<param><key>ymin</key><value>Config_values.LowFreqBoundary</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Filtered"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>40240</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.01</value></param>
<param><key>tr_level</key><value>0.03</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>10060</value></param>
<param><key>srate</key><value>Config_values.TransmissionSampRate</value></param>
<param><key>tr_delay</key><value>0.01</value></param>
<param><key>tr_level</key><value>-0.1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_slope</key><value>qtgui.TRIG_SLOPE_NEG</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_3</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>40240</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_2_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_transmitter</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>20</value></param>
<param><key>samp_rate</key><value>Config_values.TransmissionSampRate</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>frequency_carrier</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>20.7</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>frequency_carrier</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>100</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>Config_values.TransmissionSampRate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>bandwith</value></param>
<param><key>center_freq0</key><value>frequency_carrier</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>100</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>ui</value></param>
<param><key>source_code</key><value>#!/usr/bin/env python
import Tkinter as tk

class ui(tk.Frame):
    def __init__(self, master=None):
        tk.Frame.__init__(self, master)
        self.grid()
        self.createWidgets()

    def createWidgets(self):
        self.quitButton = tk.Button(self, text='Quit',
            command=self.quit)
        self.quitButton.grid()
</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>variable_qtgui_range_00</value></param>
<param><key>const</key><value>variable_qtgui_range_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>PPM_Analog_RC_PPM_Peak_Detector_0</source_block_id><sink_block_id>PPM_Analog_RC_PPM_Signal_Detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PPM_Analog_RC_PPM_Peak_Detector_0</source_block_id><sink_block_id>PPM_Demodulator</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PPM_Analog_RC_PPM_Peak_Detector_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PPM_Analog_RC_PPM_Signal_Detector_0</source_block_id><sink_block_id>probing_block</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PPM_Analog_RC_PPM_Signal_Detector_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>PPM_Modulator</source_block_id><sink_block_id>variable_qtgui_range_00</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>add_const_transmitter</source_block_id><sink_block_id>analog_wfm_tx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>add_const_transmitter</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>add_const_transmitter</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>root_raised_cosine_transmitter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_tx</source_block_id><sink_block_id>uhd_usrp_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>PPM_Analog_RC_PPM_Peak_Detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>PPM_Analog_RC_PPM_Signal_Detector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_rms_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_time_sink_x_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>moving_average</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_transmitter</source_block_id><sink_block_id>multiply_const_transmitter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_transmitter</source_block_id><sink_block_id>qtgui_waterfall_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>moving_average</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>moving_average</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>multiply_const_transmitter</source_block_id><sink_block_id>add_const_transmitter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_transmitter</source_block_id><sink_block_id>low_pass_filter_transmitter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>variable_qtgui_range_00</source_block_id><sink_block_id>root_raised_cosine_transmitter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
