options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: added
  id: variable_qtgui_range
  parameters:
    start: '-1'
    step: '0.001'
    stop: '1'
    value: '-0.4'
  states: {}
- name: bandwith
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: frequency_carrier
  id: variable
  parameters:
    value: 72.170e6
  states: {}
- name: multiplied
  id: variable_qtgui_range
  parameters:
    start: '-100'
    step: '1'
    stop: '0'
    value: '-17'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: PPM_Analog_RC_PPM_Demodulator_0
  id: PPM_Analog_RC_PPM_Demodulator
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: PPM_Analog_RC_PPM_Modulator_0
  id: PPM_Analog_RC_PPM_Modulator
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: PPM_Analog_RC_PPM_Peak_Detector_0
  id: PPM_Analog_RC_PPM_Peak_Detector
  parameters:
    peak_threshold: '0'
  states: {state: disabled}
- name: PPM_Analog_RC_PPM_Signal_Detector_0
  id: PPM_Analog_RC_PPM_Signal_Detector
  parameters:
    energy_threshold: '1'
    samp_rate: samp_rate
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_IMPULSE
    seed: '0'
    type: float
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    deemph_tau: '75e-6'
    quad_rate: bandwith
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '250000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '250000'
    tau: '75e-6'
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: added
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/simon/Workspace/TC-16-17/PFE/2-PPM_Analog_RC/GNU-Radio/PPM_Analog_RC.dat
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: multiplied
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bandwith
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 'bandwith '
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 2e3
    decim: '1'
    gain: '100'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    size: '10240'
    srate: samp_rate
    tr_delay: '0.01'
    tr_level: '0.09'
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    gain: '1'
    interp: '1'
    ntaps: '150'
    samp_rate: samp_rate
    sym_rate: '1.0'
    type: interp_fir_filter_fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: frequency_carrier
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: frequency_carrier
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '100'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: bandwith
    center_freq0: frequency_carrier
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '100'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [PPM_Analog_RC_PPM_Modulator_0, '0', root_raised_cosine_filter_0, '0']
- [PPM_Analog_RC_PPM_Peak_Detector_0, '0', PPM_Analog_RC_PPM_Demodulator_0, '0']
- [PPM_Analog_RC_PPM_Peak_Detector_0, '0', PPM_Analog_RC_PPM_Signal_Detector_0, '0']
- [PPM_Analog_RC_PPM_Signal_Detector_0, '0', qtgui_time_sink_x_0, '0']
- [analog_noise_source_x_0, '0', root_raised_cosine_filter_0, '0']
- [analog_wfm_rcv_0, '0', low_pass_filter_1, '0']
- [analog_wfm_tx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_add_const_vxx_0_0, '0', analog_wfm_tx_0, '0']
- [blocks_complex_to_mag_0, '0', PPM_Analog_RC_PPM_Signal_Detector_0, '1']
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', PPM_Analog_RC_PPM_Peak_Detector_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_const_vxx_0, '0']
- [root_raised_cosine_filter_0, '0', low_pass_filter_0_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-104-g8ccb8e65
